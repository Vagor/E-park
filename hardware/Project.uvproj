# Keil uVision project Project.uvproj, settings and files
target 工程 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group 源码
    ./源码/: main.c 24C02.c RC522.C CTRL.c LCD12864.c
